## src/drivers/smart_battery/batmon/Kconfig
```kconfig
menuconfig DRIVERS_SMART_BATTERY_BATMON
	bool "batmon"
	default y
	---help---
		Enable support for batmon
```
